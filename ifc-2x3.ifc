Properties of the parts of a building model (IFC2X3)

# File
Description: Anlegetemperaturfühler, PT 100, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9050010, Anlegetemperaturfühler, PT 100
In: Raum
Description: Die Anlegetemperaturfühler ALF werden zur Temperaturerfassung an Leitungen, Rohren oder Heizungsträgern eingesetzt. Zur besseren Temperaturübertragung zwischen Rohr und Anlegefühler wird die Verwendung von Wärmeleitpaste empfohlen.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9050010; ModelLabel: ALFP 100; GlobalTradeItemNumber: 4050528038050; ProductURL: https://alre.de/produkt_G9050010
Pset_Specification - NominalLength: 0.064 m; NominalWidth: 0.058 m; NominalDepth: 0.034 m; NetWeight: 0.12
Pset_ALRE_ETIM_Properties - Gehäusefarbe: weiß; Mit Gehäuse: yes; Art der Spannungsversorgung: ohne; Geeignet für Rohrmontage: yes; Umgebungstemperatur: -30; Deckelbefestigung: Bajonettverschluss; Explosionsgeschützt: no; Schutzart (IP): IP65; Mit Befestigungsmaterial: yes; Temperaturmessbereich: -30; Sensorelement innerhalb des Gehäuses: yes; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensorelement außerhalb des Gehäuses: no; Sensortyp: Pt100; Gehäusehöhe: 64; Gehäusebreite: 58; Gehäusetiefe: 34; Festes Kabel am Sensor: no; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9050010.pdf
